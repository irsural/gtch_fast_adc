# IAR project gtch_fast_adc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205rx ST STM32F205rx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IRS_STM32F2xx; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa039, Pe261, Pe340, Pa091, Pa089, Go005
  ICCARM.CCIncludePath2: ..\mxsrclib\arch\arm\; ..\mxsrclib\; ..\extern_libs\st\STM32F2xx_StdPeriph_Lib\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\extern_libs\st\STM32F2xx_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\extern_libs\st\STM32F2x7_ETH_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: gtch_fast_adc.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  group app
    ./: adc_rms.cpp adc_rms.h defs.h generator.cpp generator.h gtch.cpp gtch.h gtchcfg.cpp gtchcfg.h gtchint.cpp gtchint.h interrupt_generator.cpp interrupt_generator.h main.cpp old.h sinus_generator.cpp sinus_generator.h
  group lib/arch
    ../mxsrclib/arch/arm/: armadc.cpp armadc.h armcfg.cpp armcfg.h armeth.cpp armeth.h armflash.cpp armflash.h armgpio.h armiomacros.h armioregs.h armregs_cortex_m3.h armregs_lm3s.h armregs_stm32.h armregs_stm32f2xx.h armspi.cpp armspi.h counter.cpp counter.h irsarchint.cpp irsarchint.h irsarmutil.h mxifal.h mxnetda.h
  group lib/general
    ../mxsrclib/: correct_alg.cpp correct_alg.h csvwork.cpp csvwork.h dbgprn.cpp dbgprn.h hardflowg.cpp hardflowg.h irs_chart_data.cpp irsadc.cpp irsadc.h irsadcabs.h irsalg.cpp irsalg.h irscalc.cpp irscalc.h irschartwin.h irsconfig.h irsconfig0.h irsconsole.h irsconsolestd.h irscpp.h irscpu.cpp irscpu.h irsdacabs.h irsdbgutil.cpp irsdbgutil.h irsdefs.h irsdev.cpp irsdev.h irsdsp.cpp irsdsp.h irserror.cpp irserror.h irsexcept.cpp irsexcept.h irsfilter.cpp irsfilter.h irsfinal.h irsfunnel.cpp irsfunnel.h irsgpio.cpp irsgpio.h irsinit.cpp irsinit.h irsint.cpp irsint.h irskbd.cpp irskbd.h irslimits.h irslocale.cpp irslocale.h irsmath.cpp irsmath.h irsmatrix.cpp irsmatrix.h irsmbus.cpp irsmbus.h irsmcutil.cpp irsmcutil.h irsmem.cpp irsmem.h irsmenu.cpp irsmenu.h irsnetdefs.h irsparamabs.h irspch.h irsprop.cpp irsprop.h irsrect.h irsspi.h irsstd.cpp irsstd.h irsstrconv.h irsstrdefs.h irsstring.cpp irsstring.h irsstrm.cpp irsstrm.h irsstrmstd.h irssysutils.h irstable.h irstcpip.cpp irstcpip.h irstest.h irstime.cpp irstime.h irstree.h irsvariant.cpp irsvariant.h measdef.h measmul.cpp measmul.h meassup.cpp meassup.h mxdata.cpp mxdata.h mxdatastd.h mxextbase.cpp mxextbase.h mxextchart.cpp mxextchart.h mxifa.h mxifar.cpp mxifar.h mxnet.cpp mxnet.h mxnetc.cpp mxnetc.h mxnetd.h mxnetr.cpp mxnetr.h niusbgpib.cpp niusbgpib.h niusbgpib_hardflow.cpp niusbgpib_hardflow.h timer.cpp timer.h tstlan4abs.h
  group STM32F2x7_ETH_Driver
    ../extern_libs/st/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph_Lib
    ../extern_libs/st/STM32F2xx_StdPeriph_Lib/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
